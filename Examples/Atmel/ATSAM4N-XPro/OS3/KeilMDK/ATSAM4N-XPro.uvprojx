# Keil uVision project ATSAM4N-XPro.uvprojx, settings and files
target ATSAM4N-XPro (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ATSAM4N16C Atmel
  pack: Keil.SAM4_DFP.1.6.1
  cpu: IROM(0x00400000,0x100000) IRAM(0x20000000,0x14000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: ATSAM4N-XPro
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __SAM4N16C__, SAM4N, SAM, BOARD=61
  c include: ..\..\OS3;..\..\BSP;..\..\BSP\OS\uCOS-III;..\..\BSP\KeilMDK;..\..\BSP\Atmel;..\..\BSP\Atmel\include;..\..\BSP\Atmel\common\services\delay;..\..\BSP\Atmel\common\services\clock;..\..\BSP\Atmel\common\boards;..\..\..\..\..\Software\uC-CPU;..\..\..\..\..\Software\uC-CPU\ARM-Cortex-M4\RealView;..\..\..\..\..\Software\uC-LIB;..\..\..\..\..\Software\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\..\..\..\..\Software\uCOS-III\Source;..\..\..\..\..\Software\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\Shell;..\..\..\..\..\Software\uC-Shell\Source;..\..\..\..\..\Software\uC-Shell\Terminal\Source;..\..\..\..\..\Software\uC-Shell\Cmd\General;..\..\uGUI
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group APP
    ../: app.c os_app_hooks.c app_key.c
  group BSP
    ../../BSP/KeilMDK/: cstartup.s
    ../../BSP/: cpu_bsp.c bsp.c bsp_int.c bsp_ser.c bsp_spi.c bsp_ssd1306.c ssd1306_font.c
    ../../BSP/OS/uCOS-III/: bsp_os.c
  group uC/CPU
    ../../../../../Software/uC-CPU/: cpu_core.c
    ../../../../../Software/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
  group uC/LIB
    ../../../../../Software/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../../../../Software/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uC/OS-III Source
    ../../../../../Software/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC/OS-III Port
    ../../../../../Software/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_c.c os_cpu_a.asm
  group uC/Shell
    ../../../../../Software/uC-Shell/Terminal/Source/: terminal.c
    ../../../../../Software/uC-Shell/Terminal/OS/uCOS-III/: terminal_os.c
    ../../../../../Software/uC-Shell/Terminal/Mode/VT100/: terminal_mode.c
    ../../Shell/: terminal_serial.c
    ../../../../../Software/uC-Shell/Source/: shell.c
    ../../../../../Software/uC-Shell/Cmd/General/: sh_shell.c
  group SAM4N Library
    ../../BSP/Atmel/: system_SAM4N.c
    ../../BSP/Atmel/drivers/pmc/: pmc.c
    ../../BSP/Atmel/drivers/uart/: uart.c
    ../../BSP/Atmel/drivers/pio/: pio.c
    ../../BSP/Atmel/drivers/spi/: spi.c
    ../../BSP/Atmel/common/services/delay/sam/: cycle_counter.c
  group uGUI
    ../../uGUI/: ugui.c
software components: CMSIS:CORE 4.3.0
