# Keil uVision project frdm-kl25z.uvprojx, settings and files
target FRDM-KL25Z (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IROM(0x00000000,0x00020000) IRAM(0x1FFFF000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: frdm-kl25z
  AfterMake: fromelf --m32combined --output=Objects/outfile.s19  Objects/frdm-kl25z.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\OS3;..\..\BSP;..\..\BSP\KeilMDK;..\..\BSP\OS\uCOS-III;..\..\BSP\Freescale;..\..\..\..\..\Software\uC-CPU;..\..\..\..\..\Software\uC-CPU\ARM-Cortex-M0\RealView;..\..\..\..\..\Software\uC-LIB;..\..\..\..\..\Software\uCOS-III\Source;..\..\..\..\..\Software\uCOS-III\Ports\ARM-Cortex-M0\Generic\RealView;..\..\Shell;..\..\..\..\..\Software\uC-Shell\Source;..\..\..\..\..\Software\uC-Shell\Terminal\Source;..\..\..\..\..\Software\uC-Shell\Cmd\General
  asm misc: --cpreproc
  asm include: ..\..\OS3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group APP
    ../: app.c os_app_hooks.c
  group BSP
    ../../BSP/: bsp.c bsp_int.c bsp_ser.c cpu_bsp.c
    ../../BSP/OS/uCOS-III/: bsp_os.c
    ../../BSP/KeilMDK/: cstartup.s
  group uC/CPU
    ../../../../../Software/uC-CPU/: cpu_core.c
    ../../../../../Software/uC-CPU/ARM-Cortex-M0/RealView/: cpu_a.asm cpu_c.c
  group uC/LIB
    ../../../../../Software/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC/OS-III Source
    ../../../../../Software/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC/OS-III Port
    ../../../../../Software/uCOS-III/Ports/ARM-Cortex-M0/Generic/RealView/: os_cpu_a.s os_cpu_c.c
  group uC/Shell
    ../../../../../Software/uC-Shell/Terminal/Source/: terminal.c
    ../../../../../Software/uC-Shell/Terminal/OS/uCOS-III/: terminal_os.c
    ../../../../../Software/uC-Shell/Terminal/Mode/VT100/: terminal_mode.c
    ../../Shell/: terminal_serial.c
    ../../../../../Software/uC-Shell/Source/: shell.c
    ../../../../../Software/uC-Shell/Cmd/General/: sh_shell.c
